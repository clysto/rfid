options:
  parameters:
    author: Yachen Mao
    generate_options: no_gui
    id: rfid_query
    output_language: python
    run_options: run
    title: Query RFID
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: f"{out}_A.cf32"
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: 2.dat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: 2.cf32
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_2
  id: blocks_file_sink
  parameters:
    file: f"{out}_B.cf32"
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: reader.f32
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * duration)
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * (duration + 0.2))
    type: complex
  states: {}
- name: blocks_head_0_1
  id: blocks_head
  parameters:
    num_items: int(samp_rate * 0.05)
    type: complex
  states: {state: disabled}
- name: blocks_head_0_2
  id: blocks_head
  parameters:
    num_items: int(samp_rate * 0.05)
    type: complex
  states: {state: disabled}
- name: blocks_head_0_3
  id: blocks_head
  parameters:
    num_items: int(samp_rate * duration)
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate * 0.003)
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate * 0.003)
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate * 0.003)
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0_2
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate * 0.003)
    type: complex
  states: {}
- name: duration
  id: parameter
  parameters:
    label: Duration
    type: eng_float
    value: '0.1'
  states: {}
- name: out
  id: parameter
  parameters:
    label: Output Name
    type: str
    value: rx
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: Rx Gain
    type: intx
    value: '0'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: Tx Gain
    type: intx
    value: '20'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 910e6
    gain0: tx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: 910e6
    center_freq1: 910e6
    dc_offs_enb0: disabled
    dc_offs_enb1: disabled
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_head_0_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_head_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_head_0_2, '0', blocks_file_sink_0_1, '0']
- [blocks_head_0_3, '0', blocks_file_sink_0_2, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [blocks_skiphead_0_0, '0', blocks_head_0_1, '0']
- [blocks_skiphead_0_1, '0', blocks_head_0_2, '0']
- [blocks_skiphead_0_2, '0', blocks_head_0_3, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']
- [uhd_usrp_source_0, '1', blocks_skiphead_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
