options:
  parameters:
    author: Yachen Mao
    generate_options: no_gui
    id: rfid_query
    output_language: python
    run_options: run
    title: Query RFID
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx.cf32
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: reader.f32
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * 0.05)
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * 0.06)
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(samp_rate * 0.003)
    type: complex
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: Rx Gain
    type: intx
    value: '0'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: Tx Gain
    type: intx
    value: '80'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 910e6
    gain0: tx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 910e6
    dc_offs_enb0: disabled
    gain0: rx_gain
    iq_imbal_enb0: disabled
    samp_rate: samp_rate
    sd_spec0: A:B
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_head_0_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
