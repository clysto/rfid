options:
  parameters:
    author: Yachen Mao
    generate_options: no_gui
    id: rfid_query
    output_language: python
    run_options: run
    title: Query RFID
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * duration)
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate * (duration + 0.2))
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: reader_cmd_gen(samp_rate, tag_filter)
  states: {}
- name: duration
  id: parameter
  parameters:
    label: Duration
    type: eng_float
    value: '0.1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 900e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from command_gen import reader_cmd_gen
  states: {}
- name: out
  id: parameter
  parameters:
    label: Output Name
    type: str
    value: rx.cf32
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: Rx Gain
    type: intx
    value: '0'
  states: {}
- name: tag_filter
  id: parameter
  parameters:
    label: Filter
    short_id: f
    type: str
    value: all
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: Tx Gain
    type: intx
    value: '20'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    dc_offs_enb0: disabled
    gain0: rx_gain
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_head_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
